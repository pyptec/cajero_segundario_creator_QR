# Keil uVision project Creator.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RD2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: Creator jp +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Sec_Creator LPR RenewM CtrlLuz
  group Source Group 1
    ./: Creator.C uart.c debug.c CRT_288.c ptoprlelo.c lector.c
